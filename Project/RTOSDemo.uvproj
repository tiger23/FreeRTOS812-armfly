# Keil uVision project RTOSDemo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\CORTEX_STM32F103_Keil;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOS\include;..\bsp\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Demo Files
    ./ParTest/: ParTest.c
    ./serial/: serial.c
    ../Common/Minimal/: semtest.c BlockQ.c blocktim.c comtest.c death.c flash.c integer.c PollQ.c
    ../bsp/: FreeRTOSConfig.h stm32f10x_conf.h main.c spi_flash.c timertest.c
  group FreeRTOS files
    ../../Source/: tasks.c list.c queue.c
    ../FreeRTOS/: croutine.c timers.c
  group Liararies
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
